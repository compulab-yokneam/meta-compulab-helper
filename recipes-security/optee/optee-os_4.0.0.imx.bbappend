EXTRA_OEMAKE += "CFG_UART_BASE=UART4_BASE"
