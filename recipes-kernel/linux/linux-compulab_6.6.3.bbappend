FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-6.6.3-ucm-imx8m-plus-Add-uart4-debug-console-support.patch"

