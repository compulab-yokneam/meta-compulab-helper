FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-ucm-imx8m-plus-Add-uart4-debug-console-support.patch \
            file://0002-ucm-imx8m-plus-Disable-uart2.patch \
"
